# Append path for ts layer to include bsp pointercal.xinput
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
