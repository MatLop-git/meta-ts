PACKAGECONFIG:append = " sql-sqlite sql-mysql icu accessibility"
